## sdkconfig.defaults
```kconfig
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
# CONFIG_LV_CONF_SKIP is not set
CONFIG_XPT2046_Z_THRESHOLD=400
CONFIG_XPT2046_CONVERT_ADC_TO_COORDS=1
```
